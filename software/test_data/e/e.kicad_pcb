File: software/test_data/e/e.kicad_pcb (KiCad board)
At the start: 2 copper layers, 0 parts

Commit message: olin O
Parts:
- added G***: LOGO, footprints:olin_negative, F.Cu at (27.9, 16.5)
