File: software/test_data/name_tag/name_tag.kicad_pcb (KiCad board)
At the start: 2 copper layers, 1 part

Commit message: go away edges
Parts:
- moved G*** 5.68 mm to (47.0, 34.3)
